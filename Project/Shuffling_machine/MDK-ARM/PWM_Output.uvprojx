# Keil uVision project PWM_Output.uvprojx, settings and files
target N32WB452 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: N32WB452LEQ6 Nationstech
  pack: Nationstech.N32WB452_DFP.1.0.4
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PWM_Output
  AfterMake: fromelf --bin --output=.\bin\PWM_Output.bin .\Objects\PWM_Output.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32WB452, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\firmware\CMSIS\core;..\..\..\firmware\CMSIS\device;..\..\..\firmware\n32wb452_std_periph_driver\inc;..\..\bsp\inc;..\..\..\FatFs\source;..\..\..\FreeRtos\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group STARTUP
    ../../../firmware/CMSIS/device/startup/: startup_n32wb452.s
  group CMSIS
    ../../../firmware/CMSIS/device/: system_n32wb452.c
  group FWLB
    ../../../firmware/n32wb452_std_periph_driver/src/: misc.c n32wb452_adc.c n32wb452_dma.c n32wb452_exti.c n32wb452_flash.c n32wb452_gpio.c n32wb452_rtc.c n32wb452_rcc.c n32wb452_tim.c n32wb452_wwdg.c n32wb452_usart.c n32wb452_i2c.c n32wb452_spi.c
  group USER
    ../src/: main.c n32wb452_it.c oled.c timer.c System_Init.c gui.c key.c flash.c
    ../../bsp/src/: log.c delay.c
  group DOC
    ../: readme.txt
  group FatFs
    ../../../FatFs/source/: diskio.c ff.c
  group FreeRtos
    ../../../FreeRtos/Scr/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../FreeRtos/port/ARM_CM4F/: port.c
    ../../../FreeRtos/port/MemMang/: heap_4.c
